# Keil uVision project stm32f103zet6.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Core\Inc;..\Drivers\HAL_Driver\Inc;..\App\Inc;..\Drivers\BSP\Inc;..\Drivers\Port\Inc;..\Drivers\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Drivers/BSP
    ../Drivers/BSP/Src/: adc_init.c clock_init.c dht11_init.c fsmc_init.c gpio_init.c hal_init.c nvic_init.c tim_init.c uart_init.c driver_dht11.c driver_lcd.c
  group App
    ../App/Src/: app.c app_alarm_control.c app_env_sensor.c app_key_handler.c app_mode_control.c app_uart_report.c main.c app_lcd_display.c
  group Drivers/Port
    ../Drivers/Port/Src/: port_impl_adc_stm32f103zet6.c port_impl_gpio_stm32f103zet6.c port_impl_par_stm32f103zet6.c port_impl_timer_stm32f103zet6.c port_impl_uart_stm32f103zet6.c
  group Core
    ../Core/Src/: stm32f10x_it.c system_stm32f10x.c
    ../Core/Startup/: startup_stm32f10x_hd.s
  group HalDriver
    ../Drivers/HAL_Driver/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
